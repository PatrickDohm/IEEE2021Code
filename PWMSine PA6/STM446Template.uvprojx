# Keil uVision project STM446Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM446Template
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: PWMSine.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 2.6.0
